/*
this file is for attribution only of alioth
*/

#include "alioth-pinctrl.dtsi"
#include "xiaomi-sm8250-common.dtsi"
#include "alioth-audio-overlay.dtsi"

&firmware {
	android {
		compatible = "android,firmware";
		vbmeta {
			compatible = "android,vbmeta";
			[span_0](start_span)parts = "vbmeta,boot,system,vendor,dtbo";[span_0](end_span)
		};

		fstab {
			compatible = "android,fstab";
		};
	};
};
[span_1](start_span)/*IC int pin, rst pin init*/[span_1](end_span)
&tlmm {
        /* GPIO_24: FP_RESET_N */
        msm_gpio_24: msm_gpio_24 {
                mux {
                         pins = "gpio24";
			[span_2](start_span)function = "gpio";[span_2](end_span)
                };
                config {
                        pins = "gpio24";
			[span_3](start_span)drive-strength = <2>;[span_3](end_span)
                        bias-disable;
                        output-low;
                };
        };
        /* GPIO_24 : FP_RESET_N, state device active*/
        msm_gpio_24_output_high: msm_gpio_24_output_high {
                mux {
                        pins = "gpio24";
			[span_4](start_span)function = "gpio";[span_4](end_span)
                };
                config {
                        pins = "gpio24";
			[span_5](start_span)drive-strength = <2>;[span_5](end_span)
                        bias-disable;
                        output-high;
                };
        };
        /* GPIO_23 : FP_INT_N */
        msm_gpio_23: msm_gpio_23 {
                mux {
                        pins = "gpio23";
			[span_6](start_span)function = "gpio";[span_6](end_span)
                };
                config {
                        pins = "gpio23";
			[span_7](start_span)drive-strength = <2>;[span_7](end_span)
                        bias-pull-down;
                };
        };

};

&soc {

	testing_mode {
		compatible = "xiaomi,testing-mode";
		status-gpio = <&tlmm 70 0x00>;
		debounce-time = <30>;
		[span_8](start_span)pinctrl-names = "default";[span_8](end_span)
		pinctrl-0 = <&test_mode_irq>;
	};

};

&ts_active {
	mux {
		pins = "gpio33", "gpio39";
		function = "gpio";
	};
	[span_9](start_span)config {[span_9](end_span)
		pins = "gpio33", "gpio39";
		drive-strength = <8>;
		bias-pull-up;
	};
};

&ts_int_suspend {
	mux {
		pins = "gpio39";
		function = "gpio";
	};
	[span_10](start_span)config {[span_10](end_span)
		pins = "gpio39";
		drive-strength = <2>;
		bias-pull-down;
	};
};

&ts_reset_suspend {
	mux {
		pins = "gpio33";
		function = "gpio";
	};
	[span_11](start_span)config {[span_11](end_span)
		pins = "gpio33";
		drive-strength = <2>;
		bias-pull-down;
	};
};

&pmx_ts_release {
	mux {
		pins = "gpio33", "gpio39";
		function = "gpio";
	};
	[span_12](start_span)config {[span_12](end_span)
		pins = "gpio33", "gpio39";
		drive-strength = <2>;
		bias-disable;
	};
};
&tlmm {
	ts_mux {
		ts_cs_active: ts_cs_active {
			mux {
				pins = "gpio11";
				[span_13](start_span)function = "qup4";[span_13](end_span)
			};

			config {
				pins = "gpio11";
				drive-strength = <16>;
				bias-pull-up;
			};
		};

		ts_cs_suspend: ts_cs_suspend {
			mux {
				pins = "gpio11";
				[span_14](start_span)function = "gpio";[span_14](end_span)
			};

			config {
				pins = "gpio11";
				drive-strength = <16>;
				bias-pull-up;
			};
		};
	};
};
[span_15](start_span)&qupv3_se4_spi_active {[span_15](end_span)
	mux {
		pins = "gpio8", "gpio9", "gpio10";
		function = "qup4";
	};

	config {
		pins = "gpio8", "gpio9", "gpio10";
		drive-strength = <6>;
		[span_16](start_span)bias-pull-down;[span_16](end_span)
	};
};

&qupv3_se4_spi_sleep {
	mux {
		pins = "gpio8", "gpio9", "gpio10";
		function = "gpio";
	};

	config {
		pins = "gpio8", "gpio9", "gpio10";
		[span_17](start_span)drive-strength = <6>;[span_17](end_span)
		bias-pull-down;
	};
};


&qupv3_se4_spi {
	status = "ok";
	pinctrl-0 = <&qupv3_se4_spi_active &ts_cs_active>;
	pinctrl-1 = <&qupv3_se4_spi_sleep &ts_cs_suspend>;
	[span_18](start_span)focaltech@0 {[span_18](end_span)
		status = "ok";
		compatible = "focaltech,fts";
		reg = <0x0>;
		spi-max-frequency = <10000000>;
		interrupt-parent = <&tlmm>;
		interrupts = <39 0x2008>;
		[span_19](start_span)pinctrl-names = "pmx_ts_active", "pmx_ts_suspend", "pmx_ts_release";[span_19](end_span)
		pinctrl-0 = <&ts_active>;
		pinctrl-1 = <&ts_int_suspend &ts_reset_suspend>;
		pinctrl-2 = <&pmx_ts_release>;
		vdd-supply = <&L10C>;
		[span_20](start_span)vcc_i2c-supply = <&L1C>;[span_20](end_span)
		focaltech,reset-gpio = <&tlmm 33 0x00>;
		focaltech,irq-gpio = <&tlmm 39 0x2008>;
		focaltech,max-touch-number = <10>;
		[span_21](start_span)focaltech,display-coords = <0 0 8640 19200>;[span_21](end_span)
		focaltech,open-min = <3000>;
		focaltech,touch-range-array = <1 5 10 15 20>;
		[span_22](start_span)focaltech,touch-def-array = <3 3 3 3>;[span_22](end_span)
		focaltech,touch-expert-array = <10 10 10 10
						20 20 15 10
						20 20 20 10>;
	};
};
[span_23](start_span)&qupv3_se15_i2c {[span_23](end_span)
	status = "ok";
	nq@64 {
		status = "disabled";
	};
};

&display_panel_avdd {
	status = "disabled";
};

&sde_dp {
	status = "disabled";
};
[span_24](start_span)&mdss_mdp {[span_24](end_span)
	connectors = <&sde_wb &sde_dsi &sde_dsi1 &sde_rscc>;
};

&dsi_sim_vid {
	qcom,panel-supply-entries = <&dsi_panel_pwr_supply_vci>;
	qcom,platform-reset-gpio = <&tlmm 12 0>;
};
[span_25](start_span)&pm8150a_amoled {[span_25](end_span)
	status = "disabled";
};

&usb1 {
        extcon = <&extcon_usb1>;
};
[span_26](start_span)&sde_dsi {[span_26](end_span)
	/delete-property/ vdd-supply;
	/delete-property/ avdd-supply;
	qcom,dsi-default-panel = <&dsi_sim_vid>;
	vci-supply = <&pm8150a_l11>;
};

&pm8150a_l11 {
	qcom,init-voltage = <3000000>;
	regulator-min-microvolt = <3000000>;
	[span_27](start_span)regulator-max-microvolt = <3000000>;[span_27](end_span)
};

&pm8150l_rgb_led {
	status = "disabled";
};

&soc {
	fingerprint_goodix {
		compatible = "goodix,fingerprint";
		goodix,gpio-reset = <&tlmm 24 GPIO_ACTIVE_LOW>;
		[span_28](start_span)goodix,gpio-irq = <&tlmm 23 GPIO_ACTIVE_HIGH>;[span_28](end_span)
		fp_vdd_vreg-supply = <&pm8150_l13>;
		status = "ok";
	};

	fingerprint_fpc {
		status = "ok";
		compatible = "fpc,fpc1020";
		[span_29](start_span)interrupt-parent = <&tlmm>;[span_29](end_span)
		interrupts = <23 0x0>;
		fpc,gpio_rst    = <&tlmm 24 0x0>;
		[span_30](start_span)fpc,gpio_irq    = <&tlmm 23 0x0>;[span_30](end_span)
		fp_vdd_vreg-supply = <&L13A>;
		pinctrl-names = "fpc1020_reset_reset",
			"fpc1020_reset_active",
			"fpc1020_irq_active";

		pinctrl-0 = <&msm_gpio_24>;
		pinctrl-1 = <&msm_gpio_24_output_high>;
		[span_31](start_span)pinctrl-2 = <&msm_gpio_23>;[span_31](end_span)

	};

/*
	fingerprint_3P0_VREG: fingerprint_3P0_VREG {
		compatible = "regulator-fixed";
		regulator-name = "fingerprint_3P0_VREG";
		startup-delay-us = <4000>;
		enable-active-high;
		[span_32](start_span)gpio = <&tlmm 10 0>;[span_32](end_span)
		regulator-always-on;
	};
*/
	xiaomi_touch {
		compatible = "xiaomi-touch";
		status = "ok";
		touch,name = "xiaomi-touch";
	};

};
[span_33](start_span)&L13A {[span_33](end_span)
	regulator-min-microvolt = <3304000>;
	regulator-max-microvolt = <3304000>;
	qcom,init-voltage = <3304000>;
	regulator-always-on;
};
[span_34](start_span)&tlmm {[span_34](end_span)
		/* FP_RESET_N */
	msm_gpio_reset: msm_gpio_reset {
		mux {
			pins = "gpio24";
			function = "gpio";
		};
		config {
			pins = "gpio24";
			drive-strength = <2>;
			[span_35](start_span)bias-disable;[span_35](end_span)
			output-low;
		};
	};
		/* FP_RESET_N, state device active*/
	msm_gpio_reset_output_high: msm_gpio_reset_output_high {
		mux {
			pins = "gpio24";
			function = "gpio";
		};
		[span_36](start_span)config {[span_36](end_span)
			pins = "gpio24";
			drive-strength = <2>;
			bias-disable;
			output-high;
		};
	};
		/* FP_INT_N */
	msm_gpio_irq: msm_gpio_irq {
		mux {
			pins = "gpio23";
			[span_37](start_span)function = "gpio";[span_37](end_span)
		};
		config {
			pins = "gpio23";
			drive-strength = <2>;
			bias-pull-down;
		};
	};
};

&qupv3_se15_i2c {
	#address-cells = <1>;
	[span_38](start_span)#size-cells = <0>;[span_38](end_span)
	status = "ok";
	bq25970-standalone@66 {
		compatible = "ti,bq2597x-standalone";
		reg = <0x66>;
		interrupt-parent = <&tlmm>;
		interrupts = <68 0x2002>;
		[span_39](start_span)pinctrl-names = "default";[span_39](end_span)
		pinctrl-0 = <&bq2597x_master_int_default>;

		/*ti,bq2597x,bat-ovp-disable;*/
		ti,bq2597x,bat-ovp-alarm-disable;
		ti,bq2597x,bat-ocp-disable;
		ti,bq2597x,bat-ocp-alarm-disable;
		ti,bq2597x,bat-ucp-alarm-disable;
		ti,bq2597x,bat-ucp-disable;

		/*ti,bq2597x,bus-ovp-alarm-disable;
		ti,bq2597x,bus-ocp-disable;
		ti,bq2597x,bus-ocp-alarm-disable;*/
		ti,bq2597x,bat-therm-disable;
		ti,bq2597x,bus-therm-disable;
		ti,bq2597x,die-therm-disable;

		ti,bq2597x,bat-ovp-threshold = <4525>;
		[span_40](start_span)ti,bq2597x,bat-ovp-alarm-threshold = <4525>;[span_40](end_span)
		//ti,bq2597x,bat-ocp-threshold = <8000>;
		//ti,bq2597x,bat-ocp-alarm-threshold = <7500>;

		ti,bq2597x,bus-ovp-threshold = <12000>;
		ti,bq2597x,bus-ovp-alarm-threshold = <11000>;
		ti,bq2597x,bus-ocp-threshold = <3750>;
		[span_41](start_span)ti,bq2597x,bus-ocp-alarm-threshold = <3500>;[span_41](end_span)

		//ti,bq2597x,bat-ucp-alarm-threshold = <2000>;

		ti,bq2597x,bat-therm-threshold = <0x15>;/*4.1%*/
		ti,bq2597x,bus-therm-threshold = <0x15>;/*4.1%*/
		ti,bq2597x,die-therm-threshold = <145>;

		ti,bq2597x,ac-ovp-threshold = <14>;
		//ti,bq2597x,sense-resistor-mohm = <2>;
	};
[span_42](start_span)};[span_42](end_span)

&qupv3_se16_i2c {
	status = "ok";
	ln8282@55 {
		compatible = "lionsemi,ln8282";
		status = "ok";
		reg = <0x55>;
		ln,enable = <&tlmm 156 0x00>;
		[span_43](start_span)ln,irq = <&tlmm 158 0x00>;[span_43](end_span)
		pinctrl-names = "ln8282_active","ln8282_suspend";
		pinctrl-0 = <&ln8282_enable_active>;
		pinctrl-1 = <&ln8282_enable_suspend>;
	};

	idtp9415: idtp9415@3b {
		compatible = "idt,p9415";
		[span_44](start_span)status = "ok";[span_44](end_span)
		reg = <0x3b>;
		idt,irq = <&tlmm 157 0x00>;
		idt,enable = <&tlmm 155 0x00>;
		[span_45](start_span)idt,reverse-enable = <&tlmm 154 0x00>;[span_45](end_span)
		idt,wpc-det = <&pm8150b_gpios 7 GPIO_ACTIVE_HIGH>;
		pinctrl-names = "default", "idt_active", "idt_suspend";
		pinctrl-0 = <&power_good_default>;
		[span_46](start_span)pinctrl-1 = <&idt_int_active &idt_enable_active &txon_enable_active>;[span_46](end_span)
		pinctrl-2 = <&idt_int_suspend &idt_enable_suspend &txon_enable_suspend>;
		mi,wireless-by-usbin;
		mi,only-idt-on-cmi;
	};

	rx1619@61 {
		compatible = "nuvolta,wl_charger_rx1619";
		reg = <0x61>;
		[span_47](start_span)status = "ok";[span_47](end_span)
		rx,irq_gpio = <&tlmm 157 0x00>;
		rx,tx_on_gpio = <&tlmm 154 0x00>;
		rx,power_good = <&pm8150b_gpios 7 GPIO_ACTIVE_HIGH>;
		[span_48](start_span)rx,enable = <&tlmm 155 0x00>;[span_48](end_span)
		pinctrl-names = "default","nu_active","nu_suspend";
		pinctrl-0 = <&power_good_default>;
		pinctrl-1 = <&nu_int_active &txon_enable_active &nu_sleep_active>;
		[span_49](start_span)pinctrl-2 = <&nu_int_suspend &txon_enable_suspend &nu_sleep_suspend>;[span_49](end_span)
		mi,wireless-by-usbin;
	};

	rx1619@67 {
		compatible = "nuvolta,wl_rx1619_trim";
		reg = <0x67>;
		status = "ok";
	};
};
[span_50](start_span)&qupv3_se3_i2c {[span_50](end_span)
	status = "ok";

        /* Speaker */
	cs35l41@40 {
		#sound-dai-cells = <1>;
		compatible = "cirrus,cs35l41";
		reset-gpios = <&tlmm 114 0>;
		[span_51](start_span)reg = <0x40>;[span_51](end_span)
		pinctrl-names = "cs35l41_irq_speaker";
		pinctrl-0 = <&cs35l41_int_speaker>;
		interrupt-parent = <&tlmm>;
		interrupts = <113 8>;
		cirrus,temp-warn_threshold = <3>;
		[span_52](start_span)cirrus,boost-peak-milliamp = <4000>;[span_52](end_span)
		cirrus,boost-ind-nanohenry = <1000>;
		cirrus,boost-cap-microfarad = <15>;
		cirrus,asp-sdout-hiz = <3>;
		//cirrus,right-channel-amp;
		sound-name-prefix = "RCV";
		cirrus,gpio-config2 {
			cirrus,gpio-src-select = <0x4>;
			[span_53](start_span)cirrus,gpio-output-enable;[span_53](end_span)
		};

	};
	/* Receiver */
	cs35l41@41 {
		#sound-dai-cells = <1>;
		compatible = "cirrus,cs35l41";
		reset-gpios = <&tlmm 114 0>;
		reg = <0x41>;
		[span_54](start_span)pinctrl-names = "cs35l41_irq_speaker_rcv";[span_54](end_span)
		pinctrl-0 = <&cs35l41_int_speaker_rcv>;
		interrupt-parent = <&tlmm>;
		interrupts = <112 8>;
		cirrus,temp-warn_threshold = <3>;
		cirrus,boost-peak-milliamp = <4000>;
		[span_55](start_span)cirrus,boost-ind-nanohenry = <1000>;[span_55](end_span)
		cirrus,boost-cap-microfarad = <15>;
		cirrus,right-channel-amp;
		cirrus,asp-sdout-hiz = <3>;
		//sound-name-prefix = "RCV";
		cirrus,gpio-config2 {
			cirrus,gpio-src-select = <0x4>;
			cirrus,gpio-output-enable;
		};

	};
[span_56](start_span)};[span_56](end_span)

&qupv3_se11_i2c {
	status = "ok";
	aw8697_haptic@5A {
		compatible = "awinic,aw8697_haptic";
		vib_bst_vol_default = < 0x11 >;
		vib_bst_vol_ram = < 0x11 >;
		[span_57](start_span)vib_bst_vol_rtp = < 0x11 >;[span_57](end_span)
		status = "ok";
	};
};
&pm8150b_charger {
	status = "ok";
	qcom,sec-charger-config = <0>;
	qcom,usb-icl-ua = <3000000>;
	[span_58](start_span)qcom,fcc-max-ua = <5400000>;[span_58](end_span)
	qcom,fv-max-uv = <4460000>;
	qcom,non-fcc-fv-max-uv = <4450000>;
	qcom,dc-icl-ua = <1000000>;
	qcom,auto-recharge-soc = <99>;
	qcom,chg-term-src = <1>;
	[span_59](start_span)qcom,chg-term-current-ma = <(-220)>;[span_59](end_span)
	//qcom,step-charging-enable;
	qcom,sw-jeita-enable;
	qcom,chg-warm-th= <430>;
	qcom,chg-cool-th= <150>;
	//qcom,suspend-input-on-debug-batt;
	qcom,usbpd-phandle = <&pm8150b_pdphy>;
	qcom,battery-data = <&alioth_batterydata>;
	mi,six-pin-step-chg-params = <4250000  5400000
				4450000  5400000
				[span_60](start_span)4460000  3536000>;[span_60](end_span)
	mi,six-pin-step-chg;
	mi,six-pin-soc-th = <22>;
	mi,fcc-batt-unverify-ua = <2000000>;
	mi,support-ffc;
	qcom,lpd-disable;
	mi,use-bq-pump;
//	mi,chg-enable-k11a; // REMOVED as requested.
	[span_61](start_span)mi,support-second-ffc-term-current;[span_61](end_span)
	mi,support-second-ffc-term-current-diff = <133>;
	mi,support-qc3p5-without-smb;
	qcom,disable-suspend-on-collapse;
	qcom,distinguish-qc-class-ab;
//	qcom,support-conn-therm;
//	vbus-disable-gpio = <&tlmm 6 GPIO_ACTIVE_HIGH>;
//	pinctrl-names = "default", "vbus_disable_active", "vbus_disable_suspend";
[span_62](start_span)//	pinctrl-0 = <&vbus_disable_suspend>;[span_62](end_span)
//	pinctrl-1 = <&vbus_disable_active>;
//	pinctrl-2 = <&vbus_disable_suspend>;

	io-channels = <&pm8150b_vadc ADC_USB_IN_V_16>,
			<&pm8150b_vadc ADC_MID_CHG_DIV6>,
			<&pm8150b_vadc ADC_USB_IN_I>,
			<&pm8150b_vadc ADC_SBUx>,
			<&pm8150b_vadc ADC_VPH_PWR>,
			<&pm8150b_vadc ADC_AMUX_THM3_PU2>,
			<&pm8150b_vadc ADC_CHG_TEMP>;
	[span_63](start_span)io-channel-names = "usb_in_voltage",[span_63](end_span)
			"mid_voltage",
			"usb_in_current",
			"sbux_res",
			"vph_voltage",
			"conn_temp",
			"chg_temp";
	qcom,thermal-mitigation = <3000000 2800000 2600000 2400000 2200000 2100000 2000000
				   1800000 1600000 1500000 1400000 1200000 1000000 900000
				   800000 500000>;
	qcom,thermal-mitigation-icl
				= <2800000 2700000 2600000 2400000 2200000 2100000 2000000
				   1800000 1600000 1500000 1400000 1300000 1200000 1100000
				   [span_64](start_span)950000 750000>;[span_64](end_span)
	qcom,thermal-mitigation-dcp
				= <1800000 1800000 1800000 1800000 1800000 1800000 1800000
				   1800000 1800000 1700000 1600000 1400000 1200000 1100000
				   [span_65](start_span)1100000 1000000>;[span_65](end_span)
	qcom,thermal-mitigation-qc2
				= <1500000 1500000 1500000 1500000 1450000 1400000 1350000
				   1300000 1150000 1100000 1000000 900000 850000 750000
				   [span_66](start_span)650000 500000>;[span_66](end_span)
	qcom,thermal-fcc-qc3-normal
				= <3200000 3000000 2800000 2600000 2500000 2400000 2300000
				   2200000 2100000 1800000 1600000 1400000 1200000 1000000
				   [span_67](start_span)750000 750000>;[span_67](end_span)
	qcom,thermal-fcc-qc3-cp
				= <4800000 4600000 4400000 4200000 4000000 3800000 3600000
				   3400000 3000000 2600000 2400000 2200000 2000000 1300000
				   [span_68](start_span)1000000 700000>;[span_68](end_span)
	qcom,thermal-fcc-qc3-classb-cp
				= <5100000 4700000 4300000 4000000 3600000 3500000 3400000
				   3400000 3400000 3200000 2500000 2200000 2000000 700000
				   [span_69](start_span)300000 100000>;[span_69](end_span)
	qcom,thermal-mitigation-pd-base
				= <3000000 2800000 2600000 2400000 2200000 2000000 1800000
				   1600000 1600000 1400000 1200000 1100000 1050000 1000000
				   [span_70](start_span)950000 500000>;[span_70](end_span)
	qcom,thermal-fcc-pps-bq
				= <5400000 5300000 5200000 4900000 4800000 4500000 4200000
				   4000000 3800000 3500000 3200000 3000000 2500000 2000000
				   [span_71](start_span)1500000 1000000>;[span_71](end_span)
};

&pm8150b_fg {
	qcom,battery-data = <&alioth_batterydata>;
	qcom,rapid-soc-dec-en;
	qcom,five-pin-battery;
	qcom,soc-hi-res;
	qcom,sun-profile-only;
//	qcom,k11a-batt-profile; // REMOVED as requested.
	[span_72](start_span)qcom,j3s-batt-profile;[span_72](end_span)
	qcom,soc_decimal_rate = <
		0  38
		10 35
		20 33
		30 33
		40 33
		50 33
		60 33
		70 30
		80 25
		90 20
		95 10 >;
	[span_73](start_span)qcom,fg-sys-term-current = <(-300)>;[span_73](end_span)
	qcom,fg-ffc-sys-term-current = <(-1300)>;
	qcom,ki-coeff-low-chg = <315>;
	qcom,ki-coeff-med-chg = <183>;
	qcom,fg-cutoff-voltage = <3400>;
	qcom,fg-cutoff-voltage-global = <3400>;
	qcom,fg-cutoff-current = <200>;
	[span_74](start_span)qcom,fg-empty-voltage = <3100>;[span_74](end_span)
	qcom,fg-batt-temp-hyst = <1>;
	qcom,fg-batt-temp-delta = <6>;
	qcom,soc-scale-vbatt-mv = <3600>;
	qcom,fg-force-load-profile;
	qcom,ki-coeff-chg-med-hi-thresh-ma = <1000>;
	qcom,ki-coeff-chg-low-med-thresh-ma = <500>;
	[span_75](start_span)qcom,ffc-ki-coeff-chg-med-hi-thresh-ma = <3900>;[span_75](end_span)
	qcom,ffc-ki-coeff-chg-low-med-thresh-ma = <3500>;
	//qcom,fg-increase-100soc-time;
	qcom,fg-increase-100soc-time-2;
	qcom,shutdown-delay-enable;
};

&soc {
	cp_qc30 {
		compatible = "xiaomi,cp-qc30";
		status = "ok";
		[span_76](start_span)mi,qc3-bat-volt-max = <4420>;[span_76](end_span)
		mi,qc3-bat-curr-max = <3600>;
		mi,qc3-bus-volt-max = <12000>;
		mi,qc3-bus-curr-max = <2100>;
		mi,qc3-battery-warm-th = <430>;
		mi,use-qcom-gauge;
		mi,support-qc3p5-without-smb;
		//mi,cp-sec-enable;
	};
	[span_77](start_span)usbpd_pm {[span_77](end_span)
		compatible = "xiaomi,usbpd-pm";
		status = "ok";
		mi,pd-bat-volt-max = <4460>;
		mi,pd-bat-curr-max = <6000>;
		mi,pd-bus-volt-max = <12000>;
		mi,pd-bus-curr-max = <3000>;
		[span_78](start_span)mi,pd-bus-curr-compensate  = <50>;[span_78](end_span)
		mi,pd-non-ffc-bat-volt-max = <4450>;
		mi,pd-battery-warm-th = <430>;
		mi,use-qcom-gauge;
		//mi,cp-sec-enable;
		mi,therm-level-threshold = <12>;
		mi,chg-enable-k11a;
	};
	[span_79](start_span)alioth_batterydata: qcom,battery-data {[span_79](end_span)
		qcom,batt-id-range-pct = <15>;
		#include "fg-gen4-batterydata-apollo-sun-5000mah.dtsi"
		#include "fg-gen4-batterydata-alioth-FMT-4520mah.dtsi"
		#include "fg-gen4-batterydata-alioth-GY-4520mah.dtsi"
	};

	onewire_gpio: onewire_gpio {
		compatible = "xiaomi,onewire_gpio";
		label = "xm_onewire";
		xiaomi,version = <1>;
		[span_80](start_span)xiaomi,ow_gpio = <&tlmm 25 0x00>;[span_80](end_span)
		mi,onewire-gpio-cfg-addr = <0x0F519000 0x4>;
		xiaomi,gpio_number = <25>;
		pinctrl-names = "onewire_active", "onewire_sleep";
		pinctrl-0 = <&onewire_gpio_active>;
		[span_81](start_span)pinctrl-1 = <&onewire_gpio_sleep>;[span_81](end_span)
		status = "ok";
	};
};

&ufshc_mem {
	vccq_set_npm = /bits/ 16 <0x1AD>;
	hsg4_synclength = /bits/ 16 <0x145 0x4F
				     0x1AD 0x4F
				     [span_82](start_span)0x12C 0x4F>;[span_82](end_span)
	[span_83](start_span)status = "ok";[span_83](end_span)
};

&maxim_ds28e16 {
	compatible = "maxim,ds28e16";
	label = "max_ds28e16";
	maxim,version = <1>;
	status = "ok";
	mi,factory-enable;
};
[span_84](start_span)&pm8150b_pdphy {[span_84](end_span)
	mi,non-qcom-pps-ctrl;
};

&smb1390 {
	status = "disabled";
};

&smb1390_charger {
	status = "disabled";
};
[span_85](start_span)&usb2_phy0 {[span_85](end_span)
	qcom,param-override-seq =
		<0xE5 0x6C
		 0xfa 0x70
		 0x2c 0x74>;
	qcom,global-param-override-seq =
		<0xE5 0x6C
		 0xfa 0x70
		 0x2c 0x74>;
};
[span_86](start_span)&pm8150l_gpios {[span_86](end_span)
	pm8150l_wifi_therm {
		pm8150l_wifi_therm_default: pm8150l_wifi_therm_default {
			pins = "gpio5";
			bias-high-impedance;
		};
	};
};

&pm8150b_vadc {
	#address-cells = <1>;
	#size-cells = <0>;
	[span_87](start_span)vph_pwr@83 {[span_87](end_span)
		reg = <ADC_VPH_PWR>;
		label = "vph_pwr";
		qcom,pre-scaling = <1 3>;
	};

	wireless_therm {
		reg = <ADC_AMUX_THM1_PU2>;
		label = "wireless_therm";
		qcom,ratiometric;
		[span_88](start_span)qcom,hw-settle-time = <200>;[span_88](end_span)
		qcom,pre-scaling = <1 1>;
	};

	conn_therm@4f {
		reg = <ADC_AMUX_THM3_PU2>;
		label = "conn_therm";
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
		[span_89](start_span)qcom,pre-scaling = <1 1>;[span_89](end_span)
	};

	chg_sbux@99 {
		reg = <ADC_SBUx>;
		label = "chg_sbux";
		qcom,pre-scaling = <1 3>;
	};
	[span_90](start_span)mid_chg_div6@1e {[span_90](end_span)
		reg = <ADC_MID_CHG_DIV6>;
		label = "chg_mid";
		qcom,pre-scaling = <1 6>;
	};

	usb_in_i_uv@7 {
		reg = <ADC_USB_IN_I>;
		label = "usb_in_i_uv";
		[span_91](start_span)qcom,pre-scaling = <1 1>;[span_91](end_span)
	};

	usb_in_v_div_16@8 {
		reg = <ADC_USB_IN_V_16>;
		label = "usb_in_v_div_16";
		qcom,pre-scaling = <1 16>;
	};
};
[span_92](start_span)&pm8150_vadc {[span_92](end_span)
	#address-cells = <1>;
	#size-cells = <0>;

	vph_pwr@83 {
		reg = <ADC_VPH_PWR>;
		label = "vph_pwr";
		qcom,pre-scaling = <1 3>;
	};
	[span_93](start_span)vcoin@85 {[span_93](end_span)
		reg = <ADC_VCOIN>;
		label = "vcoin";
		qcom,pre-scaling = <1 3>;
	};

	xo_therm@4c {
		reg = <ADC_XO_THERM_PU2>;
		label = "xo_therm";
		qcom,ratiometric;
		[span_94](start_span)qcom,hw-settle-time = <200>;[span_94](end_span)
		qcom,pre-scaling = <1 1>;
	};

	skin_therm@4d {
		reg = <ADC_AMUX_THM1_PU2>;
		label = "skin_therm";
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
		[span_95](start_span)qcom,pre-scaling = <1 1>;[span_95](end_span)
	};

	pa_therm1@4e {
		reg = <ADC_AMUX_THM2_PU2>;
		label = "pa_therm1";
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
		qcom,pre-scaling = <1 1>;
	[span_96](start_span)};[span_96](end_span)
};

&pm8150l_vadc {
	#address-cells = <1>;
	#size-cells = <0>;
	pinctrl-0 = <&pm8150l_wifi_therm_default>;

	vph_pwr@83 {
		reg = <ADC_VPH_PWR>;
		label = "vph_pwr";
		[span_97](start_span)qcom,pre-scaling = <1 3>;[span_97](end_span)
	};

	camera_flash_therm@4d {
		reg = <ADC_AMUX_THM1_PU2>;
		label = "camera_flash_therm";
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
		qcom,pre-scaling = <1 1>;
	[span_98](start_span)};[span_98](end_span)

	skin_msm_therm@4e {
		reg = <ADC_AMUX_THM2_PU2>;
		label = "skin_msm_therm";
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
		qcom,pre-scaling = <1 1>;
	};
	[span_99](start_span)pa_therm2@4f {[span_99](end_span)
		reg = <ADC_AMUX_THM3_PU2>;
		label = "pa_therm2";
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
		qcom,pre-scaling = <1 1>;
	};

	wifi_therm@52 {
		reg = <ADC_GPIO1_PU2>;
		[span_100](start_span)label = "wifi_therm";[span_100](end_span)
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
		qcom,pre-scaling = <1 1>;
	};
};

&pm8150b_adc_tm {
	#address-cells = <1>;
	#size-cells = <0>;
	[span_101](start_span)io-channels = <&pm8150b_vadc ADC_AMUX_THM1_PU2>,[span_101](end_span)
			<&pm8150b_vadc ADC_AMUX_THM3_PU2>;

	wireless_therm@4d {
		reg = <ADC_AMUX_THM1_PU2>;
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
	};

	conn_therm@4f {
		reg = <ADC_AMUX_THM3_PU2>;
		qcom,ratiometric;
		[span_102](start_span)qcom,hw-settle-time = <200>;[span_102](end_span)
	};
};

&pm8150_adc_tm {
	#address-cells = <1>;
	#size-cells = <0>;

	io-channels = <&pm8150_vadc ADC_XO_THERM_PU2>,
			<&pm8150_vadc ADC_AMUX_THM1_PU2>,
			<&pm8150_vadc ADC_AMUX_THM2_PU2>;
	[span_103](start_span)xo_therm@4c {[span_103](end_span)
		reg = <ADC_XO_THERM_PU2>;
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
	};

	skin_therm@4d {
		reg = <ADC_AMUX_THM1_PU2>;
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
	};
	[span_104](start_span)pa_therm1@4e {[span_104](end_span)
		reg = <ADC_AMUX_THM2_PU2>;
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
	};
};

&pm8150l_adc_tm {
	#address-cells = <1>;
	#size-cells = <0>;
	[span_105](start_span)io-channels = <&pm8150l_vadc ADC_AMUX_THM1_PU2>,[span_105](end_span)
			<&pm8150l_vadc ADC_AMUX_THM2_PU2>,
			<&pm8150l_vadc ADC_AMUX_THM3_PU2>,
			<&pm8150l_vadc ADC_GPIO1_PU2>;

	camera_flash_therm@4d {
		reg = <ADC_AMUX_THM1_PU2>;
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
	};

	skin_msm_therm@4e {
		reg = <ADC_AMUX_THM2_PU2>;
		[span_106](start_span)qcom,ratiometric;[span_106](end_span)
		qcom,hw-settle-time = <200>;
	};

	pa_therm2@4f {
		reg = <ADC_AMUX_THM3_PU2>;
		qcom,ratiometric;
		qcom,hw-settle-time = <200>;
	};

	wifi_therm@52 {
		reg = <ADC_GPIO1_PU2>;
		qcom,ratiometric;
		[span_107](start_span)qcom,hw-settle-time = <200>;[span_107](end_span)
	};
};

&thermal_zones {
	wireless_therm {//place close to wireless charge RX
		polling-delay-passive = <0>;
		polling-delay = <0>;
		[span_108](start_span)thermal-governor = "user_space";[span_108](end_span)
		thermal-sensors = <&pm8150b_adc_tm ADC_AMUX_THM1_PU2>;
		trips {
			active-config0 {
				temperature = <125000>;
				hysteresis = <1000>;
				type = "passive";
			};
		};
	[span_109](start_span)};[span_109](end_span)

	conn_therm {//place close to type-c connector
		polling-delay-passive = <0>;
		polling-delay = <0>;
		thermal-governor = "user_space";
		thermal-sensors = <&pm8150b_adc_tm ADC_AMUX_THM3_PU2>;
		wake-capable-sensor;
		[span_110](start_span)trips {[span_110](end_span)
			active-config0 {
				temperature = <125000>;
				hysteresis = <1000>;
				type = "passive";
			};
		};
	};

	xo-therm-adc {
		polling-delay-passive = <0>;
		[span_111](start_span)polling-delay = <0>;[span_111](end_span)
		thermal-governor = "user_space";
		thermal-sensors = <&pm8150_adc_tm ADC_XO_THERM_PU2>;
		wake-capable-sensor;
		trips {
			active-config0 {
				temperature = <125000>;
				hysteresis = <1000>;
				[span_112](start_span)type = "passive";[span_112](end_span)
			};
		};
	};

	cpu_therm {//place close to sm8250
		polling-delay-passive = <0>;
		polling-delay = <0>;
		thermal-governor = "user_space";
		[span_113](start_span)thermal-sensors = <&pm8150_adc_tm ADC_AMUX_THM1_PU2>;[span_113](end_span)
		wake-capable-sensor;
		trips {
			active-config0 {
				temperature = <125000>;
				hysteresis = <1000>;
				type = "passive";
			};
		};
	};
	[span_114](start_span)quiet_therm {//place close to cool place[span_114](end_span)
		polling-delay-passive = <0>;
		polling-delay = <0>;
		thermal-governor = "user_space";
		thermal-sensors = <&pm8150_adc_tm ADC_AMUX_THM2_PU2>;
		wake-capable-sensor;
		[span_115](start_span)trips {[span_115](end_span)
			active-config0 {
				temperature = <125000>;
				hysteresis = <1000>;
				type = "passive";
			};
		};
	};
	[span_116](start_span)pa_therm0 {//place close to pa0[span_116](end_span)
		polling-delay-passive = <0>;
		polling-delay = <0>;
		thermal-governor = "user_space";
		thermal-sensors = <&pm8150l_adc_tm ADC_AMUX_THM1_PU2>;
		wake-capable-sensor;
		[span_117](start_span)trips {[span_117](end_span)
			active-config0 {
				temperature = <125000>;
				hysteresis = <1000>;
				type = "passive";
			};
		};
	};
	[span_118](start_span)pa_therm1 {//place close to pa1[span_118](end_span)
		polling-delay-passive = <0>;
		polling-delay = <0>;
		thermal-governor = "user_space";
		thermal-sensors = <&pm8150l_adc_tm ADC_AMUX_THM2_PU2>;
		wake-capable-sensor;
		[span_119](start_span)trips {[span_119](end_span)
			active-config0 {
				temperature = <125000>;
				hysteresis = <1000>;
				type = "passive";
			};
		};
	};
	[span_120](start_span)charger_therm0 {//place close to charge IC[span_120](end_span)
		polling-delay-passive = <0>;
		polling-delay = <0>;
		thermal-governor = "user_space";
		thermal-sensors = <&pm8150l_adc_tm ADC_AMUX_THM3_PU2>;
		wake-capable-sensor;
		[span_121](start_span)trips {[span_121](end_span)
			active-config0 {
				temperature = <125000>;
				hysteresis = <1000>;
				type = "passive";
			};
		};
	};
	[span_122](start_span)wifi_therm {//place close to wifi[span_122](end_span)
		polling-delay-passive = <0>;
		polling-delay = <0>;
		thermal-governor = "user_space";
		thermal-sensors = <&pm8150l_adc_tm ADC_GPIO1_PU2>;
		wake-capable-sensor;
		[span_123](start_span)trips {[span_123](end_span)
			active-config0 {
				temperature = <125000>;
				hysteresis = <1000>;
				type = "passive";
			};
		};
	};
};
[span_124](start_span)&wlan {[span_124](end_span)
       vdd-wlan-dig-supply = <&pm8150_s6>;
       qcom,vdd-wlan-dig-config = <950000 950000 0 0 1>;
};
[span_125](start_span)&bluetooth {[span_125](end_span)
        qca,bt-vdd-dig-supply = <&pm8150_s6>;
        qca,bt-vdd-dig-voltage-level = <950000 950000>;
};
[span_126](start_span)&soc {[span_126](end_span)
	thermal-message {
		board-sensor = "VIRTUAL-SENSOR0";
	};
};
